# WR qemuarma9 configuration, not supported in Yocto
KBRANCH:qemuarma9 ?= "v5.14/standard/arm-versatile-926ejs"
KERNEL_DEVICETREE:qemuarma9 = "vexpress-v2p-ca9.dtb"
COMPATIBLE_MACHINE:qemuarma9 = "qemuarma9"
